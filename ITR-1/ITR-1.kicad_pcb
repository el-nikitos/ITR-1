# Repository el-nikitos/ITR-1

## KiCad design ITR-1/ITR-1.kicad_pcb

Parts:
A1: модуль_esp32_wroom_32_SMD_noSD; ESP32_WROOM32_pnp_noSD
C1, C2: Конденсатор_керамический; Конденсатор_SMD_IEC_0805
C3, C4, C5: Конденсатор_керамический; Конденсатор_SMD_0603_pnp
D1: LOGO; ni_10x10
D2: LOGO; VLAD_10x10
DA1: ОУ_LMV321ILT; SOT-23-5_pnp
DD1: Микросхема_заряда_MCP73831T-2ACI_OT; SOT-23-5_pnp
FU1: Предохранитель_MF-MSMF030; Предохранитель_SMD_1812
G2: ИОП_LM4040BIM3-2.5_NOPB; Транзистор_IRLML6344TR_SOT-23
HL2: Светодиод_сдвоенный_KPB-3025SURKCGKC; Светодиод_SMD_m3025
K1, K2: Кнопка_KLS7-TS5401-1.35-250-T; Кнопка_KLS7-TS5401
K3, K4: кнопка; Кнопка_FSMSM
R1, R2, R3, R5, R6, R7, R8, R9, R10, R11, R12, R13, R14, R15, R17, R18, R19, R20, R25, R26: Резистор_0,065Вт; Резистор_SMD_0603_0,065_Вт
VD1: Диоды_шоттки_BAR43CFILM; Транзистор_IRLML6344TR_SOT-23
VD5: Стабилитрон_BZV55-C3V9; SOD-80
VT1, VT3, VT4: Транзистор_полевой_P-канал(IRLML2246TRPBF); Транзистор_IRLML6344TR_SOT-23
VT2: Транзистор_полевой_N-IRLML6344TR; Транзистор_IRLML6344TR_SOT-23
X1, X2, X3, X4: отверстие_под_пайку; ОтверстиеD1.2
XS1: Клеммник_х3; jack_ST-033
XS3: UBS-type-C-105450-0101&упрощенная; usb-type-c

Connections:
/3V3: A1.2 (3V3), C3.1, C5.1, R14.1, R18.2, R26.2, VD5.2, VT3.3
/AN.2V5.REF: A1.8 (IO32/ADC1-4), DA1.3, G2.1, R12.2
/AN.BAT.MEASURE: A1.7 (IO35/ADC1-7), R10.2, R11.1
/BAT.CHARGE: C2.1, DD1.3 (VBAT), FU1.2, R1.1, VT1.2
/BAT.IN: FU1.1, X2.1
/BAT.LOAD: C4.1, DA1.5 (+VCC), R10.1, R12.1, R13.1, VT1.3, VT3.2
/BOOT: A1.25 (IO_BOOT/ADC2-1), K2.1, K2.2, R18.1
/CHARGE.MODE: A1.33 (IO21), R8.1
/EXT.BUTT: R9.2, VD1.3, X4.1
/GND: A1.1 (GND), A1.15 (GND), A1.38 (GND), A1.39 (GND), C1.2, C2.2, C3.2, C4.2, C5.2, DA1.2 (-VDD), DD1.2 (VSS/GND), G2.2, K1.3, K1.4, K2.3, K2.4, R2.2, R5.2, R7.2, R11.2, R15.2, R17.1, VD5.1, VT2.2, X1.1, X3.1, XS1.1, XS3.A1 (GND), XS3.A12 (GND), XS3.B1 (GND), XS3.B12 (GND); also elsewhere on the board
/LED1: A1.30 (IO18), HL2.1
/LED2: A1.31 (IO19), HL2.3
/OUT.RX: R19.2, XS1.2
/OUT.TX: R20.2, XS1.3
/RESET: A1.3 (EN), R25.2
/SELF.TURN: A1.29 (IO5), R3.1
/U.FB: DA1.1, R14.2, R15.1
/U.IN: VT4.3, XS3.A4 (VBUS), XS3.A9 (VBUS), XS3.B4 (VBUS), XS3.B9 (VBUS)
/U.PROTECT: C1.1, DD1.4 (VDD), R6.1, VT4.2
/UART.RX: A1.34 (RXD0), R19.1
/UART.TX: A1.35 (TXD0), R20.1
unnamed 32: A1.28 (IO17); also elsewhere on the board
unnamed: DA1.4, R13.2, VT3.1
unnamed: DD1.1 (STAT), R8.2
unnamed: DD1.5 (PROG), R7.1
unnamed: HL2.2, HL2.4, R17.2
unnamed: K1.1, K1.2, R25.1, R26.1
unnamed: R1.2, VD1.1, VD1.2, VT1.1, VT2.3
unnamed: R2.1, R3.2, VT2.1
unnamed: R5.1, R6.2, VT4.1

Notes on the sheet:
~~300 мА
-нажатие кнопки открывает транзистор питания -на линии SELF.TURN МК должен выставить высокий уровень для самоподхвата -на лии BUTT.TURN МК в режиме PULL-UP видит состояние кнопки включения
защита от переполюсовки
включение питания с самоподхватом
ПОДКЛЮЧЕНИЕ ПРОГРАММИРОВАНИЯ
СХЕМА СБРОСА

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
Board: 2 copper layers, 30.0 x 45.0 mm, 53 parts (12 on the bottom side), 34 nets.

Other parts of the board:
R4, R16: Резистор_0,065Вт; Резистор_SMD_0603_0,065_Вт
X5, X6, X7, X8: отверстие_под_пайку; ОтверстиеD1.2

Their connections:
/GND: X7.1, X8.1; also elsewhere on the board
unnamed 32: R4.2; also elsewhere on the board
unnamed: R4.1, X5.1
unnamed: R16.1, X6.1

## Commit log

2021-09-04 габаритная заготовка
2021-09-05 схема организации питания
2021-09-11 закончена схема, начата трассировка питания
2021-09-12 подготовлена трассировка питания, упрощена схема подключения периферии
2021-09-19 обновлены посадочные места и схема питания
2021-09-19 подготовлена трассировка +PNG +STP, требуется контрольная проверка
2021-09-19 причесана трассировка +PDF +GBR
2021-10-10 заготовка ПО под тестовый функционал
2021-10-16 добавлена кнопка воот, перенесен Ain, начато BT arduino
2021-10-16 заменен LDO на самопальный, уменьшена заливки, убраны дорожки под PCB
2021-10-16 ARD: добавлено отключение при 120 сек отсутствия нажатия на кнопку
2021-10-16 добавлен терминал
2021-10-17 добавлены функции клиента WI-FI в терминал: wstatus, disconnect, connect
2021-10-17 аналоговые каналы перенесены на ADC1
2021-10-17 время выключения - 300 сек (5мин)
2021-10-17 пере определены аналоговые входа (вход aref не проверен)
2021-10-18 функция АЦП ардуино заменена на функцию ЕСП
2021-10-20 добавлена отправка START/STOP серверу при нажатии кнопки
2021-10-24 изменено опорное + подключение к мотору; заготовка под 2 светодиода
2021-10-24 модифицирована тайминги обмена с сервером, LED заменен на 2хцветный
2021-10-27 посылает команду start/stop с переносом картеки
2021-11-28 зарядка через USB, в сервисный джек добавлена земля, кнопка впаивается
2021-11-30 ITR-1-1NN(45x30): +2 отв. под внеш. кнопки, -избыт. защита входов
2021-11-30 экспорт схемы PDF
2021-12-19 переопределены пины под новую плату, +доп.кнопки и LED +тестовый сервер
2021-12-19 параметры wifi для мотора, исправлен пин для статуса зарядки
